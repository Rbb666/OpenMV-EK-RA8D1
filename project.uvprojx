# Keil uVision project project.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA_DFP.5.1.0
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, ARM_MATH_CM85, NDEBUG, RT_USING_LIBC, MICROPY_PY_DISPLAY = 1, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, __FPU_PRESENT, BSP_CFG_RTOS = 2, MICROPY_PY_SENSOR = 1
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\linalg;rt-thread\components\drivers\include;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\linalg;rt-thread\components\dfs\dfs_v1\filesystems\elmfat;packages\OpenMV-v4.5.0\src\omv\alloc;rt-thread\components\drivers\include;packages\micropython-v1.13.0\lib\libm_dbl;rt-thread\components\dfs\dfs_v1\include;.;packages\micropython-v1.13.0\port\modules\machine;rt-thread\components\libc\compilers\common\include;packages\FreeRTOS_Wrapper-latest\FreeRTOS\include;packages\OpenMV-v4.5.0\src\omv;rt-thread\libcpu\arm\cortex-m85;packages\micropython-v1.13.0\ports\renesas;rt-thread\components\finsh;rt-thread\components\libc\posix\ipc;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\special;packages\OpenMV-v4.5.0\src\omv\boards;rt-thread\components\drivers\include;rt-thread\components\dfs\dfs_v1\filesystems\devfs;packages\OpenMV-v4.5.0\src\omv\ports;packages\micropython-v1.13.0\lib\utils;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\fft;packages\FreeRTOS_Wrapper-latest\FreeRTOS\portable\rt-thread;packages\CmBacktrace-v1.4.1;rt-thread\components\drivers\include;packages\micropython-v1.13.0;packages\OpenMV-v4.5.0\src\omv\modules;rt-thread\components\libc\posix\io\epoll;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;packages\OpenMV-v4.5.0\src\omv\ports\ra8;packages\micropython-v1.13.0\py;libraries\HAL_Drivers\config;packages\micropython-v1.13.0\ports\renesas\boards\EK-RA8D1;rt-thread\libcpu\arm\common;rt-thread\components\drivers\include;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\extension;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy;board\ports;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code;packages\OpenMV-v4.5.0\src\hal\cmsis\include;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\carray;packages\OpenMV-v4.5.0\src\omv\common;packages\OpenMV-v4.5.0\src\omv\sensors;rt-thread\components\drivers\include;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\numpy\ndarray;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\signal;board;packages\micropython-v1.13.0\port;packages\OpenMV-v4.5.0\src\omv\imlib;packages\OpenMV-v4.5.0;rt-thread\include;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\scipy\optimize;libraries\HAL_Drivers;rt-thread\components\drivers\include;packages\TinyUSB-v0.14.0\rt-thread;packages\OpenMV-v4.5.0\src\omv\boards\RA8;packages\TinyUSB-v0.14.0\src;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\user;packages\OpenMV-v4.5.0\src\omv\modules\ulab\code\utils;packages\micropython-v1.13.0\port\modules;rt-thread\components\libc\posix\io\eventfd;rt-thread\components\fal\inc;board\ports\mipi_lcd;packages\FreeRTOS_Wrapper-latest\FreeRTOS\include\freertos;packages\OpenMV-v4.5.0\src;packages\OpenMV-v4.5.0\src\omv\modules\ulab;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\libc\posix\io\poll
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  group cm_backtrace
    packages/CmBacktrace-v1.4.1/: cmb_port.c cm_backtrace.c cmb_flash_log.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/rtc/: rtc.c soft_rtc.c
    rt-thread/components/drivers/serial/: serial_v2.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_msd.c
  group Drivers
    board/: cam_hal.c ra8_it.c
    board/ports/mipi_lcd/: mipi_config.c
    board/ports/: mnt.c
    libraries/HAL_Drivers/: drv_common.c drv_flash.c drv_gpio.c drv_lcd.c drv_sci.c drv_sci_spi.c drv_soft_i2c.c drv_usart_v2.c
  group Fal
    rt-thread/components/fal/src/: fal_flash.c fal_rtt.c fal.c fal_partition.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group FreeRTOS
    packages/FreeRTOS_Wrapper-latest/FreeRTOS/portable/rt-thread/: port.c
    packages/FreeRTOS_Wrapper-latest/FreeRTOS/: list.c timers.c queue.c event_groups.c tasks.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group MicroPy
    packages/micropython-v1.13.0/extmod/: modubinascii.c vfs_posix.c machine_spi.c machine_signal.c modutimeq.c moduzlib.c modwebsocket.c modussl_axtls.c modure.c modframebuf.c vfs_fat_file.c vfs_fat_diskio.c modbtree.c modurandom.c moduselect.c moduhashlib.c machine_pulse.c modonewire.c virtpin.c vfs_reader.c modujson.c modussl_mbedtls.c moduheapq.c machine_i2c.c utime_mphal.c machine_pinbase.c moducryptolib.c uos_dupterm.c modwebrepl.c vfs.c vfs_posix_file.c moduwebsocket.c machine_mem.c moductypes.c
    packages/micropython-v1.13.0/py/: unicode.c nlraarch64.c binary.c objtuple.c modthread.c nlrx86.c asmx86.c emitnx64.c objobject.c nlrpowerpc.c objcell.c nlrsetjmp.c stackctrl.c repl.c objrange.c objgenerator.c builtinimport.c emitnx86.c pairheap.c modgc.c objstringio.c modio.c objproperty.c compile.c persistentcode.c objlist.c objreversed.c objstrunicode.c argcheck.c warning.c mpz.c nlrxtensa.c objdict.c objsingleton.c emitcommon.c formatfloat.c stream.c objmap.c emitnarm.c malloc.c runtime.c objboundmeth.c bc.c emitbc.c vm.c modstruct.c nlr.c objcomplex.c frozenmod.c objnamedtuple.c emitinlinethumb.c emitnxtensa.c ringbuf.c omvdummy.c nlrx64.c emitglue.c objenumerate.c objattrtuple.c mpprint.c nlrmips.c modbuiltins.c modsys.c obj.c objclosure.c gc.c showbc.c nativeglue.c nlrthumb.c emitnative.c modcmath.c emitinlinextensa.c scheduler.c objslice.c objarray.c builtinevex.c lexer.c objtype.c modmicropython.c asmxtensa.c objexcept.c emitnxtensawin.c pystack.c objint.c runtime_utils.c asmarm.c map.c vstr.c reader.c objzip.c modmath.c objpolyiter.c objfloat.c modarray.c parsenumbase.c parse.c parsenum.c qstr.c opmethods.c mpstate.c asmthumb.c sequence.c objbool.c objfun.c emitnthumb.c scope.c moduerrno.c asmbase.c smallint.c objint_mpz.c modcollections.c objint_longlong.c objdeque.c asmx64.c profile.c objmodule.c objnone.c objgetitemiter.c objfilter.c objset.c builtinhelp.c objstr.c
    packages/micropython-v1.13.0/port/: mpputsnport.c frozen_mpy.c mpgetcharport.c mphalport.c mpthreadport.c gccollect.c mpy_main.c
    packages/micropython-v1.13.0/port/modules/: modfile.c modutils.c modutime.c modusocket.c modnetwork_wlan.c modpyb.c moduos.c moduos_file.c modrtthread.c modnetwork.c modffi.c
    packages/micropython-v1.13.0/lib/mp-readline/: readline.c
    packages/micropython-v1.13.0/drivers/bus/: softqspi.c softspi.c
    packages/micropython-v1.13.0/lib/utils/: stdout_helpers.c pyexec.c interrupt_char.c mpirq.c printf.c sys_stdio_mphal.c
    packages/micropython-v1.13.0/port/native/: native_module.c easyflash_module.c
    packages/micropython-v1.13.0/lib/netutils/: netutils.c
    packages/micropython-v1.13.0/lib/timeutils/: timeutils.c
    packages/micropython-v1.13.0/port/modules/user/: moduserfunc.c
  group MicroPy-machine
    packages/micropython-v1.13.0/port/modules/machine/: machine_pwm.c machine_wdt.c machine_adc.c machine_timer.c machine_hw_spi.c machine_uart.c machine_pin.c machine_rtc.c machine_lcd.c machine_hw_i2c.c modmachine.c
  group MicroPy-omv-port
    packages/micropython-v1.13.0/ports/renesas/: machine_led.c pyb_i2c.c bufhelper.c pyb_uart.c led.c tinyusb_debug.c
  group Openmv
    packages/OpenMV-v4.5.0/src/omv/alloc/: fb_alloc.c umm_malloc.c unaligned_memcpy.c xalloc.c
    packages/OpenMV-v4.5.0/src/omv/common/: array.c factoryreset.c ff_wrapper.c mutex.c ringbuf.c sensor_utils.c usbdbg.c vospi.c
    packages/OpenMV-v4.5.0/src/omv/imlib/: agast.c apriltag.c bayer.c binary.c blob.c bmp.c clahe.c collections.c dmtx.c draw.c edge.c eye.c fast.c fft.c filter.c fmath.c font.c framebuffer.c fsort.c gif.c haar.c hog.c hough.c imlib.c integral.c integral_mw.c isp.c jpeg.c jpegd.c kmeans.c lab_tab.c lbp.c line.c lodepng.c lsd.c mathop.c mjpeg.c orb.c phasecorrelation.c png.c point.c pool.c ppm.c qrcode.c qsort.c rainbow_tab.c rectangle.c selective_search.c sincos_tab.c stats.c stereo.c template.c xyz_tab.c yuv.c zbar.c
    packages/OpenMV-v4.5.0/src/omv/modules/: py_clock.c py_display.c py_helper.c py_image.c py_imageio.c py_sensor.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/: ndarray.c ndarray_operators.c ndarray_properties.c ulab.c ulab_tools.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/: approx.c compare.c create.c filter.c numerical.c numpy.c poly.c stats.c transform.c vector.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/carray/: carray.c carray_tools.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/fft/: fft.c fft_tools.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/linalg/: linalg.c linalg_tools.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/numpy/ndarray/: ndarray_iter.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/linalg/: linalg.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/optimize/: optimize.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/: scipy.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/signal/: signal.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/scipy/special/: special.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/user/: user.c
    packages/OpenMV-v4.5.0/src/omv/modules/ulab/code/utils/: utils.c
  group Openmv-cmsis
    packages/OpenMV-v4.5.0/src/hal/cmsis/src/dsp/FastMathFunctions/: arm_cos_q15.c arm_sin_f32.c arm_cos_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q31.c arm_cos_q31.c arm_sqrt_q15.c
    packages/OpenMV-v4.5.0/src/hal/cmsis/src/dsp/CommonTables/: arm_common_tables.c arm_const_structs.c
    packages/OpenMV-v4.5.0/src/hal/cmsis/src/dsp/TransformFunctions/: arm_rfft_init_q31.c arm_rfft_init_q15.c
  group Openmv-port
    packages/OpenMV-v4.5.0/src/omv/ports/ra8/: omv_lcd.c sensor.c cambus.c omv_gpio.c
  group Openmv-Sensor
    packages/OpenMV-v4.5.0/src/omv/sensors/: ov2640.c mt9v0xx.c gc2145.c ov7725.c hm0360.c ov7690.c paj6100.c mt9m114.c frogeye2020.c ov5640.c ov7670.c lepton.c hm01b0.c ov9650.c
  group TinyUSB
    packages/TinyUSB-v0.14.0/src/class/cdc/: cdc_device.c
    packages/TinyUSB-v0.14.0/src/device/: usbd.c usbd_control.c
    packages/TinyUSB-v0.14.0/rt-thread/: usb_descriptor.c tinyusb_port.c
    packages/TinyUSB-v0.14.0/src/portable/renesas/rusb2/: dcd_rusb2.c rusb2_common.c hcd_rusb2.c
    packages/TinyUSB-v0.14.0/src/: tusb.c
    packages/TinyUSB-v0.14.0/rt-thread/bsp/renesas/: drv_tinyusb.c
    packages/TinyUSB-v0.14.0/src/common/: tusb_fifo.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
